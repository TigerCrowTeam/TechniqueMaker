options:
  parameters:
    comment: |-
      Block diagram converts big endian short integer complex 
      numbers that are sampled at 125M Samples per Second 
      into floats.
    generate_options: qt_gui
    id: waterfallint
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 125e6
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_endian_swap_0
  id: blocks_endian_swap
  parameters:
    type: s16
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/abel/Documents/PythonCode/TechniqueMaker/WDTnbnoise50KHz.WAVEFORM
    repeat: 'True'
    type: short
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/32000
    type: float
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_delay_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_endian_swap_0, '0', blocks_short_to_float_0_0, '0']
- [blocks_file_source_0, '0', blocks_endian_swap_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_float_to_complex_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
